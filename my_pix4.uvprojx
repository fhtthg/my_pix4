# Keil uVision project my_pix4.uvprojx, settings and files
target STM32F427 (ARM-ADS)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: my_pix4 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\SRC\lib\CMSIS\Include;.\SRC\lib\STM32F4xx_HAL_Driver\Inc;.\SRC\lib\STM32F4xx_HAL_Driver\Src;.\SRC\led;.\SRC\main
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./SRC/main/: main.c
    ./SRC/led/: led.c
  group LIB
    ./SRC/lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c
software components: Device:Startup 2.1.0
